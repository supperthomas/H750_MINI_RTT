# Keil uVision project first.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: first
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H750xx
  c include: .\libraries\CMSIS\Device\ST\STM32H7xx\Include;.\libraries\CMSIS\Include;.\rt-thread\include;..\H750_LED_SAMPLE;.\applications
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./applications/: main.c
    ./drivers/: board.c
    ./libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c startup_stm32h750xx.s
  group RTTHREAD
    ./rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c object.c scheduler.c thread.c timer.c
    ./rt-thread/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
